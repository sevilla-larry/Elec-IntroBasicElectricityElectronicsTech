File: S2/C19/S2C19ST7B/S2C19ST7B.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: upload S2 Chapter 19
Parts:
- L1: value 500m -> 100m
- V1: value 25 -> ${SIM.PARAMS}
